options:
  parameters:
    generate_options: qt_gui
    id: run
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import ctypes
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, lib_path='/Users/maksimromanuta/Documents/work_on_etalon/icarus_DDS/obj_dir/libdds.dylib'):
              gr.sync_block.__init__(self, name='DDS Verilator',
                                     in_sig=[np.int32], out_sig=[np.int32])
              self.lib = ctypes.CDLL(lib_path)
              self.lib.dds_init()

          def work(self, input_items, output_items):
              x = np.ascontiguousarray(input_items[0], dtype=np.int32)
              y = output_items[0]
              n = min(len(x), len(y))
              self.lib.dds_run(x.ctypes.data_as(ctypes.c_void_p),
                               y.ctypes.data_as(ctypes.c_void_p),
                               ctypes.c_int(n))
              return n
    lib_path: ''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
