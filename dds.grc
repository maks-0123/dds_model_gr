options:
  parameters:
    generate_options: qt_gui
    id: dds
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable
  parameters:
    value: '15800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: int
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '3100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: int
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: int
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/maksimromanuta/Documents/work_on_etalon/icarus_DDS/skripts/f32_IMD3.bin
    type: int
  states: {}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_1_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import ctypes
      from gnuradio import gr

      class blk_dds(gr.sync_block):
          def __init__(self, lib_path='/Users/maksimromanuta/Documents/work_on_etalon/icarus_DDS/obj_dir_dactest/libdds_dactest.dylib'):
              gr.sync_block.__init__(self, name='DDS Verilator',
                                     in_sig=[np.int32], out_sig=[np.int32])
              self.lib = ctypes.CDLL(lib_path)
              self.lib.dds_init()

          def work(self, input_items, output_items):
              x = np.ascontiguousarray(input_items[0], dtype=np.int32)
              y = output_items[0]
              n = min(len(x), len(y))
              self.lib.dds_run(x.ctypes.data_as(ctypes.c_void_p),
                               y.ctypes.data_as(ctypes.c_void_p),
                               ctypes.c_int(n))
              return n
    lib_path: '''/Users/maksimromanuta/Documents/work_on_etalon/icarus_DDS/obj_dir_dactest/libdds_dactest.dylib'''
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"in"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0.1'
    fftsize: '32768'
    grid: 'True'
    name: '"out"'
    norm_window: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"in"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"out"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_int_to_float_1, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_int_to_float_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_int_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_int_to_float_1_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_int_to_float_1_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle2_1, '0', epy_block_0_0, '0']
- [epy_block_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_0_0, '0', blocks_int_to_float_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
